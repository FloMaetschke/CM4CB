# Repository FloMaetschke/CM4CB

File README.md:

# CM4CB
Raspberry Pi CM4 Cluster Board

## About
The goal of this project is to create an ATX Board hosting multiple Raspberry Pi Compute Module 4 (CM4).

The plan is to power the board by a standard ATX power supply you would normally use.
The ethernet connection on board will use one (or multiple?) 7 port Gigabit-Ethernet switch(es) [KSZ9567S](http://ww1.microchip.com/downloads/en/DeviceDoc/KSZ9567S-Data-Sheet-DS00002393C.pdf) connected by the transformer-ICs magnetics modules [H5007NL](https://www.mouser.de/datasheet/2/336/HC500-220797.pdf).

## Software
This project is based on the latest kicad nightly build. This is required to open the official CM4io project from Raspbery Pi Foundation.

## Status
I am actually in the planning phase, designing the schematics. 

## Help Wanted
If you are also interested in developing a cluster board for raspberry pi CM4 please feel free to cotact me.

## KiCad design libs/CM4IO-KiCAD/CM4IOv5.kicad_pcb

File libs/CM4IO-KiCAD/README.TXT:

These files have been created in prerelease version 6 of KiCAD. If Version 6 isn't released yet then to use them you will need to download a nightly build of KiCAD. NB Nightly builds my have issues so please check the issue tracker.

Parts:
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole; MountingHole_2.7mm_M2.5; Part Description M2.5 mounting hole

Notes on the sheet:
Connectors ------- Dual USB microUSB
Connectors ------- FAN Battery
Connectors ------- HDMI 0 HDMI 1 CSI 0 CSI 1 DSI 0 DSI 1
Connectors ------- Ethernet SDCARD 40way RPI Jumpers
Connectors ------- DC Barrel Jack 4 pin power
Connector ------ PCIe x1

Parts:
C1: 100n; C_0402_1005Metric; Part Description 0.1uF 10% 16V Ceramic Capacitor X7R 040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
C5: 10u; C_0805_2012Metric; Part Description 10uF 10% 10V Ceramic Capacitor X7R 0805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
D1: LED Red; LED_0603_1608Metric; Part Description Red 620nm LED Indication - Discrete 2.2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
D2: LED Green; LED_0603_1608Metric; Part Description Green 572nm LED Indication - Discrete 2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
J1, J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical; Part Description 3pin 0.1" connector
J2: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical; Part Description PinHeader_2x07_P2.54mm_Vertical
J7: Micro_SD_Card_Det; SDCARD_MOLEX_503398-1892; Part Description 9 (8 + 1) Position Card Connector micro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
J8: THD-20-R; PinHeader_2x20_P2.54mm_Vertical; Part Description PinHeader_2x20_P2.54mm_Vertical
J9: THD-02-R; PinHeader_2x02_P2.54mm_Vertical; Part Description PinHeader_2x02_P2.54mm_Vertical
Module1: ComputeModule4; Raspberry-Pi-4-Compute-Module; Part Description 100 Position Connector Receptacle, Cent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
R1, R10: 1k; R_0402_1005Metric; Part Description Resistor 1K M1005 1% 63mW
R2, R3: 470R; R_0402_1005Metric; Part Description Resistor 470R M1005 1% 63mW
R4: nf; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5: 0R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part Description Resistor 0R M2012 5%
R17, R18: nf; R_0402_1005Metric; Part Description Resistor 1K M1005 1% 63mW
R29: 12K 1%; R_0402_1005Metric; Part Description Resistor 12K M1005 1% 63mW
TP3, TP5: TestPoint; TestPoint_Pad_2.0x2.0mm
U1, U2: TPD4EUSB30; USON-10_2.5x1.0mm_P0.5mm; Part Description Quad TVS diode for high speed signals (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
U3: MagJack-A70-112-331N126; TRJG0926HENL; Part Description Gigabit Ethernet Magjack
U5, U9: 74LVC1G07SE-7; SOT-353_SC-70-5; Part Description Buffer, Non-Inverting 1 Element 1 Bit p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
U18: RT9742GGJ5; SOT-23-5; Part Description Power Switch/Driver 1:1 N-Channel 1A TS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

Connections:
/+3.3v: D1.2 (A), D2.2 (A), J8.1, J8.17, Module1.84 (+3.3v_(Output)), Module1.86 (+3.3v_(Output)), R5.1, R17.1, R29.1, U3.15 (LEDY_A), U3.17 (LEDG_A), U5.5 (VCC), U18.5 (IN); also elsewhere on the board
/+5v: J8.2, J8.4, Module1.77 (+5v_(Input)), Module1.79 (+5v_(Input)), Module1.81 (+5v_(Input)), Module1.83 (+5v_(Input)), Module1.85 (+5v_(Input)), Module1.87 (+5v_(Input)), U9.5 (VCC); also elsewhere on the board
/CAM_GPIO: Module1.97 (Camera_GPIO); also elsewhere on the board
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/+1.8v: Module1.88 (+1.8v_(Output)), Module1.90 (+1.8v_(Output)), R4.1
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/AIN0: J2.5, Module1.96 (AnalogIP0)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/AIN1: J2.6, Module1.94 (AnalogIP1)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/BT_nDis: J3.3, Module1.91 (BT_nDisable)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/EEPROM_nWP: J2.4, Module1.20 (EEPROM_nWP)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/ETH_LEDG: Module1.15 (Ethernet_nLED3(3.3v)), R3.2
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/ETH_LEDY: Module1.17 (Ethernet_nLED2(3.3v)), R2.2
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO2: J8.3, Module1.58 (GPIO2)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO3: J8.5, Module1.56 (GPIO3)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO4: J8.7, Module1.54 (GPIO4)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO5: J8.29, Module1.34 (GPIO5)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO6: J8.31, Module1.30 (GPIO6)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO7: J8.26, Module1.37 (GPIO7)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO8: J8.24, Module1.39 (GPIO8)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO9: J8.21, Module1.40 (GPIO9)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO10: J8.19, Module1.44 (GPIO10)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO11: J8.23, Module1.38 (GPIO11)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO12: J8.32, Module1.31 (GPIO12)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO13: J8.33, Module1.28 (GPIO13)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO14: J8.8, Module1.55 (GPIO14)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO15: J8.10, Module1.51 (GPIO15)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO16: J8.36, Module1.29 (GPIO16)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO17: J8.11, Module1.50 (GPIO17)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO18: J8.12, Module1.49 (GPIO18)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO19: J8.35, Module1.26 (GPIO19)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO20: J8.38, Module1.27 (GPIO20)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO21: J8.40, Module1.25 (GPIO21)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO22: J8.15, Module1.46 (GPIO22)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO23: J8.16, Module1.47 (GPIO23)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO24: J8.18, Module1.45 (GPIO24)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO25: J8.22, Module1.41 (GPIO25)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO26: J8.37, Module1.24 (GPIO26)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO27: J8.13, Module1.48 (GPIO27)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/RUN_PG: J1.3, Module1.92 (RUN_PG), U9.2
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_CLK: J7.5 (CLK), Module1.57 (SD_CLK)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_CMD: J7.3 (CMD), Module1.62 (SD_CMD)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT0: J7.7 (DAT0), Module1.63 (SD_DAT0)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT1: J7.8 (DAT1), Module1.67 (SD_DAT1)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT2: J7.1 (DAT2), Module1.69 (SD_DAT2)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT3: J7.2 (DAT3/CD), Module1.61 (SD_DAT3)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DET: Module1.76 (Reserved), R18.1
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_PWR: C5.1, J7.4 (VDD), U18.1 (OUT)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_PWR_ON: Module1.75 (SD_PWR_ON), R29.2, U18.4 (EN)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SYNC_IN: J2.8, Module1.16 (Ethernet_SYNC_IN(1.8v))
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SYNC_OUT: J2.9, Module1.18 (Ethernet_SYNC_OUT(1.8v))
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TR0_TAP: J9.3, U3.11 (VC1)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TR1_TAP: J9.1, U3.12 (VC2)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TR2_TAP: J9.2, U3.13 (VC3)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TR3_TAP: J9.4, U3.14 (VC4)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD0_N: Module1.10 (Ethernet_Pair0_N), U2.4 (D2+), U2.7, U3.2 (TRD0-)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD0_P: Module1.12 (Ethernet_Pair0_P), U2.5 (D2-), U2.6, U3.1 (TRD0+)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD1_N: Module1.6 (Ethernet_Pair1_N), U2.2 (D1-), U2.9, U3.6 (TRD1-)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD1_P: Module1.4 (Ethernet_Pair1_P), U2.1 (D1+), U2.10, U3.3 (TRD1+)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD2_N: Module1.9 (Ethernet_Pair2_N), U1.4 (D2+), U1.7, U3.8 (TRD2-)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD2_P: Module1.11 (Ethernet_Pair2_P), U1.5 (D2-), U1.6, U3.7 (TRD2+)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD3_N: Module1.5 (Ethernet_Pair3_N), U1.2 (D1-), U1.9, U3.10 (TRD3-)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD3_P: Module1.3 (Ethernet_Pair3_P), U1.1 (D1+), U1.10, U3.9 (TRD3+)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/WL_nDis: J3.1, Module1.89 (WL_nDisable)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/nPWR_LED: Module1.95 (nPI_LED_PWR), U5.2
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/nRPIBOOT: J2.2, Module1.93 (nRPIBOOT)
/GLOBAL_EN: J1.1, J2.14, Module1.99 (Global_EN); also elsewhere on the board
/GPIO_VREF: Module1.78 (GPIO_VREF(1.8v/3.3v_Input)), R4.2, R5.2; also elsewhere on the board
/ID_SC: J8.28, Module1.35 (ID_SC); also elsewhere on the board
/ID_SD: J8.27, Module1.36 (ID_SD); also elsewhere on the board
/SCL0: Module1.80 (SCL0); also elsewhere on the board
/SDA0: Module1.82 (SDA0); also elsewhere on the board
/TV_OUT: J2.11; also elsewhere on the board
/nEXTRST: Module1.100 (nEXTRST); also elsewhere on the board
GND: C1.2, C5.2, J1.2, J2.1, J2.3, J2.7, J2.10, J2.12, J3.2, J7.6 (VSS), J7.11 (SHIELD), J8.6, J8.9, J8.14, J8.20, J8.25, J8.30, J8.34, J8.39, Module1.1 (GND), Module1.2 (GND), Module1.7 (GND), Module1.8 (GND), Module1.13 (GND), Module1.14 (GND), Module1.22 (GND), Module1.23 (GND), Module1.32 (GND), Module1.33 (GND), Module1.42 (GND), Module1.43 (GND), Module1.52 (GND), Module1.53 (GND), Module1.59 (GND), Module1.60 (GND), Module1.65 (GND), Module1.66 (GND), Module1.71 (GND), Module1.74 (GND), Module1.98 (GND), U1.3 (GND), U1.8 (GND), U2.3 (GND), U2.8 (GND), U3.19 (SHIELD), U3.20 (SHIELD), U5.3 (GND), U9.3 (GND), U18.2 (GND); also elsewhere on the board
unnamed: C1.1, U3.4 (CT), U3.5 (CT)
unnamed: D1.1 (K), R10.1, TP5.1
unnamed: D2.1 (K), R1.1, TP3.1
unnamed: J2.13, U9.4
unnamed: J7.9 (DET_B), R18.2
unnamed: J7.10 (DET_A), R17.2
unnamed: Module1.21 (PI_nLED_Activity), R1.2
unnamed: R2.1, U3.16 (LEDY_K)
unnamed: R3.1, U3.18 (LEDG_K)
unnamed: R10.2, U5.4

Notes on the sheet:
A button bwteen pins 13-14 can be used to wake up compute module from power down
If compute modules is awake RUN_PG will be high so the button doesn't do anything If the compute module is asleep then RUN_PG will be at 0v and so pull global enable low
Activity LED
Force RPIBOOT = Jumper Pins 1-2
Not Fitted headers
EEPROM write protect = Jumper Pins 3-4
40Way GPIO Header
GPIO Voltage select
Ethernet POE Protection
PWR LED
POE Header
CM4Lite SDCARD I/F
Ethernet

Parts:
C12, C13: 100n; C_0402_1005Metric; Part Description 0.1uF 10% 16V Ceramic Capacitor X7R 040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
J4, J5, J15, J16: Conn_01x22_Female; Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal; Part Description 22 Position FFC, FPC Connector Contacts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
J6: THD-02-R; PinHeader_2x02_P2.54mm_Vertical; Part Description PinHeader_2x02_P2.54mm_Vertical
J10, J22: 690-019-298-412; EDAC 690-019-298-412; Part Description HDMI Connector, Right Angle, 19 Contact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
Module1: ComputeModule4; Raspberry-Pi-4-Compute-Module; Part Description 100 Position Connector Receptacle, Cent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
R6, R7: 2.2K 1%; R_0402_1005Metric; Part Description Resistor 2.2K M1005 1% 63mW
U12: RT9742SNGV; SOT-23; Part Description Power Switch/Driver 1:1 N-Channel 500mA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

Connections:
/+3.3v: J4.22, J5.22, J15.22, J16.22; also elsewhere on the board
/+5v: C12.1, U12.1 (IN); also elsewhere on the board
/CAM_GPIO: J4.17, J5.17; also elsewhere on the board
/CM4_HighSpeed/CAM0_C_N: J4.8, Module1.140 (CAM0_C_N)
/CM4_HighSpeed/CAM0_C_P: J4.9, Module1.142 (CAM0_C_P)
/CM4_HighSpeed/CAM0_D0_N: J4.2, Module1.128 (CAM0_D0_N)
/CM4_HighSpeed/CAM0_D0_P: J4.3, Module1.130 (CAM0_D0_P)
/CM4_HighSpeed/CAM0_D1_N: J4.5, Module1.134 (CAM0_D1_N)
/CM4_HighSpeed/CAM0_D1_P: J4.6, Module1.136 (CAM0_D1_P)
/CM4_HighSpeed/CAM1_C_N: J5.8, Module1.127 (CAM1_C_N)
/CM4_HighSpeed/CAM1_C_P: J5.9, Module1.129 (CAM1_C_P)
/CM4_HighSpeed/CAM1_D0_N: J5.2, Module1.115 (CAM1_D0_N)
/CM4_HighSpeed/CAM1_D0_P: J5.3, Module1.117 (CAM1_D0_P)
/CM4_HighSpeed/CAM1_D1_N: J5.5, Module1.121 (CAM1_D1_N)
/CM4_HighSpeed/CAM1_D1_P: J5.6, Module1.123 (CAM1_D1_P)
/CM4_HighSpeed/CAM1_D2_N: J5.11, Module1.133 (CAM1_D2_N)
/CM4_HighSpeed/CAM1_D2_P: J5.12, Module1.135 (CAM1_D2_P)
/CM4_HighSpeed/CAM1_D3_N: J5.14, Module1.139 (CAM1_D3_N)
/CM4_HighSpeed/CAM1_D3_P: J5.15, Module1.141 (CAM1_D3_P)
/CM4_HighSpeed/DSI0_C_N: J15.8, Module1.169 (DSI0_C_N)
/CM4_HighSpeed/DSI0_C_P: J15.9, Module1.171 (DSI0_C_P)
/CM4_HighSpeed/DSI0_D0_N: J15.2, Module1.157 (DSI0_D0_N)
/CM4_HighSpeed/DSI0_D0_P: J15.3, Module1.159 (DSI0_D0_P)
/CM4_HighSpeed/DSI0_D1_N: J15.5, Module1.163 (DSI0_D1_N)
/CM4_HighSpeed/DSI0_D1_P: J15.6, Module1.165 (DSI0_D1_P)
/CM4_HighSpeed/DSI1_C_N: J16.8, Module1.187 (DSI1_C_N)
/CM4_HighSpeed/DSI1_C_P: J16.9, Module1.189 (DSI1_C_P)
/CM4_HighSpeed/DSI1_D0_N: J16.2, Module1.175 (DSI1_D0_N)
/CM4_HighSpeed/DSI1_D0_P: J16.3, Module1.177 (DSI1_D0_P)
/CM4_HighSpeed/DSI1_D1_N: J16.5, Module1.181 (DSI1_D1_N)
/CM4_HighSpeed/DSI1_D1_P: J16.6, Module1.183 (DSI1_D1_P)
/CM4_HighSpeed/DSI1_D2_N: J16.11, Module1.193 (DSI1_D2_N)
/CM4_HighSpeed/DSI1_D2_P: J16.12, Module1.195 (DSI1_D2_P)
/CM4_HighSpeed/DSI1_D3_N: J16.14, Module1.194 (DSI1_D3_N)
/CM4_HighSpeed/DSI1_D3_P: J16.15, Module1.196 (DSI1_D3_P)
/CM4_HighSpeed/HDMI0_CEC: J22.13 (CEC), Module1.151 (HDMI0_CEC)
/CM4_HighSpeed/HDMI0_CK_N: J22.12 (CK-), Module1.190 (HDMI0_CLK_N)
/CM4_HighSpeed/HDMI0_CK_P: J22.10 (CK+), Module1.188 (HDMI0_CLK_P)
/CM4_HighSpeed/HDMI0_D0_N: J22.9 (D0-), Module1.184 (HDMI0_TX0_N)
/CM4_HighSpeed/HDMI0_D0_P: J22.7 (D0+), Module1.182 (HDMI0_TX0_P)
/CM4_HighSpeed/HDMI0_D1_N: J22.6 (D1-), Module1.178 (HDMI0_TX1_N)
/CM4_HighSpeed/HDMI0_D1_P: J22.4 (D1+), Module1.176 (HDMI0_TX1_P)
/CM4_HighSpeed/HDMI0_D2_N: J22.3 (D2-), Module1.172 (HDMI0_TX2_N)
/CM4_HighSpeed/HDMI0_D2_P: J22.1 (D2+), Module1.170 (HDMI0_TX2_P)
/CM4_HighSpeed/HDMI0_HOTPLUG: J22.19 (HPD/HEAC-), Module1.153 (HDMI0_HOTPLUG)
/CM4_HighSpeed/HDMI0_SCL: J22.15 (SCL), Module1.200 (HDMI0_SCL)
/CM4_HighSpeed/HDMI0_SDA: J22.16 (SDA), Module1.199 (HDMI0_SDA)
/CM4_HighSpeed/HDMI1_CEC: J10.13 (CEC), Module1.149 (HDMI1_CEC)
/CM4_HighSpeed/HDMI1_CK_N: J10.12 (CK-), Module1.166 (HDMI1_CLK_N)
/CM4_HighSpeed/HDMI1_CK_P: J10.10 (CK+), Module1.164 (HDMI1_CLK_P)
/CM4_HighSpeed/HDMI1_D0_N: J10.9 (D0-), Module1.160 (HDMI1_TX0_N)
/CM4_HighSpeed/HDMI1_D0_P: J10.7 (D0+), Module1.158 (HDMI1_TX0_P)
/CM4_HighSpeed/HDMI1_D1_N: J10.6 (D1-), Module1.154 (HDMI1_TX1_N)
/CM4_HighSpeed/HDMI1_D1_P: J10.4 (D1+), Module1.152 (HDMI1_TX1_P)
/CM4_HighSpeed/HDMI1_D2_N: J10.3 (D2-), Module1.148 (HDMI1_TX2_N)
/CM4_HighSpeed/HDMI1_D2_P: J10.1 (D2+), Module1.146 (HDMI1_TX2_P)
/CM4_HighSpeed/HDMI1_HOTPLUG: J10.19 (HPD/HEAC-), Module1.143 (HDMI1_HOTPLUG)
/CM4_HighSpeed/HDMI1_SCL: J10.15 (SCL), Module1.147 (HDMI1_SCL)
/CM4_HighSpeed/HDMI1_SDA: J10.16 (SDA), Module1.145 (HDMI1_SDA)
/CM4_HighSpeed/HDMI_5v: C13.1, J10.18 (+5V), J22.18 (+5V), U12.2 (OUT)
/CM4_HighSpeed/SCL1: J4.20, J6.2, J15.20, R7.2
/CM4_HighSpeed/SDA1: J4.21, J6.4, J15.21, R6.2
/GPIO_VREF: R6.1, R7.1; also elsewhere on the board
/ID_SC: J6.1; also elsewhere on the board
/ID_SD: J6.3; also elsewhere on the board
/PCIE_CLK_N: Module1.112 (PCIe_CLK_N); also elsewhere on the board
/PCIE_CLK_P: Module1.110 (PCIe_CLK_P); also elsewhere on the board
/PCIE_CLK_nREQ: Module1.102 (PCIe_CLK_nREQ); also elsewhere on the board
/PCIE_RX_N: Module1.118 (PCIe_RX_N); also elsewhere on the board
/PCIE_RX_P: Module1.116 (PCIe_RX_P); also elsewhere on the board
/PCIE_TX_N: Module1.124 (PCIe_TX_N); also elsewhere on the board
/PCIE_TX_P: Module1.122 (PCIe_TX_P); also elsewhere on the board
/PCIE_nRST: Module1.109 (PCIe_nRST); also elsewhere on the board
/SCL0: J5.20, J16.20; also elsewhere on the board
/SDA0: J5.21, J16.21; also elsewhere on the board
/TV_OUT: Module1.111 (VDAC_COMP); also elsewhere on the board
/USB2_N: Module1.103 (USB2_N); also elsewhere on the board
/USB2_P: Module1.105 (USB2_P); also elsewhere on the board
/USBOTG: Module1.101 (USB_OTG_ID); also elsewhere on the board
GND: C12.2, C13.2, J4.1, J4.4, J4.7, J4.10, J4.13, J4.16, J4.19, J5.1, J5.4, J5.7, J5.10, J5.13, J5.16, J5.19, J10.2 (D2S), J10.5 (D1S), J10.8 (D0S), J10.11 (CKS), J10.17 (GND), J10.SH1 (SH), J10.SH2 (SH), J10.SH3 (SH), J10.SH4 (SH), J15.1, J15.4, J15.7, J15.10, J15.13, J15.16, J15.19, J16.1, J16.4, J16.7, J16.10, J16.13, J16.16, J16.19, J22.2 (D2S), J22.5 (D1S), J22.8 (D0S), J22.11 (CKS), J22.17 (GND), J22.SH1 (SH), J22.SH2 (SH), J22.SH3 (SH), J22.SH4 (SH), Module1.107 (GND), Module1.108 (GND), Module1.113 (GND), Module1.114 (GND), Module1.119 (GND), Module1.120 (GND), Module1.125 (GND), Module1.126 (GND), Module1.131 (GND), Module1.132 (GND), Module1.137 (GND), Module1.138 (GND), Module1.144 (GND), Module1.150 (GND), Module1.155 (GND), Module1.156 (GND), Module1.161 (GND), Module1.162 (GND), Module1.167 (GND), Module1.168 (GND), Module1.173 (GND), Module1.174 (GND), Module1.179 (GND), Module1.180 (GND), Module1.185 (GND), Module1.186 (GND), Module1.191 (GND), Module1.192 (GND), Module1.197 (GND), Module1.198 (GND), U12.3 (GND); also elsewhere on the board

Notes on the sheet:
Jumpers to be fitted if Camera0 or Display0 are used.
Camera Connectors
Display Connectors

Parts:
C25, C26, C27, C28, C43, C44: 10u 35v; C_0805_2012Metric; Part Description 10uF 10% or 20% 35V Ceramic Capacitor X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
C29, C62: 100n; C_0402_1005Metric; Part Description 0.1uF 10% 16V Ceramic Capacitor X7R 040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
C30, C31, C32, C33: 10u; C_0805_2012Metric; Part Description 10uF 10% 10V Ceramic Capacitor X7R 0805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
C45: 100uF; CP_EIA-7343-31_Kemet-D; Part Description Capacitor, SP-Cap, 100u, 6.3V, 15mR ESR
C63: nf; C_0402_1005Metric
C64: 1.2nF; C_0402_1005Metric; Part Description 1200pF 10% 10V Ceramic Capacitor X5R 04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
C65: nf; C_0402_1005Metric; Part Description 27pF 5% 50V Ceramic Capacitor C0G, NP0 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
J12: 10018783-11200TLF; PCIex1-36; Part Description PCI Express/PCI Connectors PCIE THROUGH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
L3: SRN6045TA-3R3Y; L_Bourns_SRN6045TA; Part Description 3.3µH Semi-Shielded Wirewound Inductor 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
R22: 10R; R_0402_1005Metric; Part Description Resistor 10R M1005 1% 63mW
R23: 12K 1%; R_0402_1005Metric; Part Description Resistor 12K M1005 1% 63mW
R24: 47K 1%; R_0402_1005Metric; Part Description Resistor 47K M1005 1% 63mW
R30: 15K 1%; R_0402_1005Metric; Part Description Resistor 15K M1005 1% 63mW
TP1: TestPoint; TestPoint_Pad_2.0x2.0mm
U15: AP64501SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.71x3.4mm_Th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; Part Description Buck Switching Regulator IC Positive Ad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

Connections:
/+12v: C25.1, C26.1, C27.1, C28.1, C43.1, C44.1, J12.A2 (+12V), J12.A3 (+12V), J12.B1 (+12v), J12.B2 (+12v), J12.B3 (+12v), U15.2 (VIN), U15.3 (EN); also elsewhere on the board
/PCIE_CLK_N: J12.A14 (REFCLK-); also elsewhere on the board
/PCIE_CLK_P: J12.A13 (REFCLK+); also elsewhere on the board
/PCIE_CLK_nREQ: J12.B12 (nCLKREQ); also elsewhere on the board
/PCIE_RX_N: J12.A16 (PERP0); also elsewhere on the board
/PCIE_RX_P: J12.A17 (PERN0); also elsewhere on the board
/PCIE_TX_N: J12.B14 (PETP0); also elsewhere on the board
/PCIE_TX_P: J12.B15 (PETN0); also elsewhere on the board
/PCIE_nRST: J12.A11 (nPERST); also elsewhere on the board
/PCIe-connector/+3.3v: C30.1, C31.1, C32.1, C33.1, C45.1, C65.1, J12.A5 (TCK), J12.A6 (TDI), J12.A8 (TMS), J12.A9 (+3.3V), J12.A10 (+3.3V), J12.B8 (+3.3v), J12.B9 (nTRST), J12.B10 (+3.3vAUX), L3.2, R24.1, TP1.1
GND: C25.2, C26.2, C27.2, C28.2, C30.2, C31.2, C32.2, C33.2, C43.2, C44.2, C45.2, C62.2, C63.2, C64.2, J12.A4 (GND), J12.A12 (GND), J12.A15 (GND), J12.A18 (GND), J12.B4 (GND), J12.B7 (GND), J12.B13 (GND), J12.B16 (GND), J12.B18 (GND), R30.2, U15.7 (GND), U15.9 (EP); also elsewhere on the board
unnamed: C29.1, R22.2
unnamed: C29.2, U15.1 (BST)
unnamed: C62.1, U15.4 (SS)
unnamed: C63.1, R23.1, U15.6 (COMP)
unnamed: C64.1, R23.2
unnamed: C65.2, R24.2, R30.1, U15.5 (FB)
unnamed: L3.1, R22.1, U15.8 (SW)

Notes on the sheet:
NB PCIe x1 takes a maximum of +12v @0.6A or +3.3v@3A , 10Watts combined
TX and RX have PN swaps to improve routing
3.3v @ 3.3A PSU for PCIe Only ( 12v Input )
PCIe x1 connector
